# IAR project EEPROMRW.ewp, settings and files
configuration EEPROMRW (ARM, debug)
  General.OGChipSelectEditMenu: STM32H753ZI ST STM32H753ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H753xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/M95P32; ../../../../../../Drivers/BSP/PGEEZ1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EEPROMRW.hex
  ILINK.IlinkOutputFile: EEPROMRW.out
  ILINK.IlinkIcfFile: stm32h753xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h753xx.s
  group Application/User
    ../Src/: app_eepromrw.c main.c stm32h7xx_hal_msp.c stm32h7xx_it.c stm32h7xx_nucleo.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/M95P32/: m95p32.c
  group Drivers/BSP/PGEEZ1
    ../../../../../../Drivers/BSP/PGEEZ1/: pgeez1_m95p32.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c
