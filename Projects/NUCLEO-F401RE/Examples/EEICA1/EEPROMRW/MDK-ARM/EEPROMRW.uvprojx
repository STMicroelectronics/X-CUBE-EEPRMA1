# Keil uVision project EEPROMRW.uvprojx, settings and files
target EEPROMRW (6190000::V6.19::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: EEPROMRW +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/M24256E;../../../../../../Drivers/BSP/Components/M24M01E;../../../../../../Drivers/BSP/EEICA1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c app_eepromrw.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/M24256E/: m24256e.c
    ../../../../../../Drivers/BSP/Components/M24M01E/: m24m01e.c
  group Drivers/BSP/EEICA1
    ../../../../../../Drivers/BSP/EEICA1/: eeica1_m24256e.c eeica1_m24m01e.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.6.0
